# Keil uVision project adconvertion.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: adconvertion +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 adconvertion.c digitron_drv.c IIC_drv.c digitron_drv.h IIC_drv.h IO_def.h type.h
